# Keil uVision project project.uvprojx, settings and files
target RT-Thread STM32 (ARM-ADS)
  device: STM32F205VETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\components\CMSIS\Include;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;Drivers;.\Drivers\markoi\eeprom;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;Libraries\STM32F2xx_StdPeriph_Driver\inc;applications
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c startup.c
    ./applications/: led.c global.c frequence.c
  group Drivers
    Drivers/: 24LCxx.c FM25Lx.c board.c i2c.c rtc.c serial.c stm32f2xx_it.c usart.c
    ./Drivers/markoi/eeprom/: at24c16a.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
    Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group readme
    ./applications/: readme.txt
